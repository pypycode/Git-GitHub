# Keil uVision project ADC_DMA.uvprojx, settings and files
target ADC_DMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_DMA
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: HSE_VALUE=8000000, USE_STDPERIPH_DRIVER
  c include: ..\..\ADC_DMA;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c
  group Stm32f4xx
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
